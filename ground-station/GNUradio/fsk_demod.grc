options:
  parameters:
    generate_options: qt_gui
    id: fsk_demod
    output_language: python
    title: FSK_demodulator
  states: {}

blocks:
- name: decim
  id: variable_qtgui_range
  parameters:
    label: dec
    start: '0'
    step: '1'
    stop: '10'
    value: '4'
    widget: slider
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 900e6
    step: 1e6
    stop: 930e6
    value: 915e6
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 5e3
    stop: 50e3
    value: 25e3
    widget: counter
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sq_thresh
  id: variable_qtgui_range
  parameters:
    label: sq
    min_len: '100'
    start: '-100'
    step: '1'
    stop: '0'
    value: '-75'
    widget: counter
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    frame_len: '240'
    preamble: '[85, 85, 85, 85, 85]'
    preamble_thrsh: '10'
    sync_thrsh: '3'
    sync_word: '[144, 78]'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decim) / (2 * math.pi * fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.01'
    threshold: sq_thresh
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 250e3
    decim: '4'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 50e3, 20e3)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Need to check baud rate (FSKC0 register?) from code
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Get threshhold frm freq sink
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: match to fs/(2pi*delta(f))
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: in case
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Source
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: XIR Filter
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Source
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    marker1: '0'
    name: Demod
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style1: '3'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Source
    type: complex
  states: {state: disabled}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq - 250e3
    samp_rate: samp_rate
    type: fc32
    vga: '24'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: 2fsk_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: 2fsk_demod
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', satnogs_frame_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [satnogs_frame_decoder_0, out, blocks_message_debug_0, print_pdu]
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
