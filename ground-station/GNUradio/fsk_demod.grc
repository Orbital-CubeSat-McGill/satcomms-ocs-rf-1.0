options:
  parameters:
    generate_options: qt_gui
    id: fsk_demod
    output_language: python
    title: FSK_demodulator
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 900e6
    step: 1e6
    stop: 930e6
    value: 915e6
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 5e3
    stop: 50e3
    value: 25e3
    widget: counter
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: sq_thresh
  id: variable_qtgui_range
  parameters:
    label: sq
    min_len: '100'
    start: '-100'
    step: '1'
    stop: '0'
    value: '-75'
    widget: counter
  states: {}
- name: decim
  id: variable
  parameters:
    comment: 500 kS/s after the filter, so 10 samples per symbol
    value: '16'
  states: {}
- name: offset_hz
  id: variable_qtgui_range
  parameters:
    comment: Frequency offset between the radios. Set it from the decoder's offset= output
    label: Offset (Hz)
    start: '-50e3'
    step: '500'
    stop: 50e3
    value: '0'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: One symbol, matched to the rectangular FSK pulse
    length: '10'
    max_iter: '4000'
    scale: '0.1'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Decodes the hat's MR-FSK frames from the symbol sync's soft symbols, and prints them.
      The frame logic is FrameSync in ground-station/fsk_decode.py.

      expect='tx-burst'  -> bit-error count against the tx-burst pattern
      expect='greenbear' -> parse the Green Bear header (ground-station/greenbear_packet.py)
                            and flag seq gaps, like `fsk_decode.py --expect greenbear`
      """
      import os
      import sys

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """OCS-RF frame decoder"""

          def __init__(self, expect='greenbear'):
              gr.sync_block.__init__(self, name='OCS-RF frame decoder', in_sig=[np.float32], out_sig=None)
              self.expect = expect
              self.fd = None
              self.gbp = None
              self.frames = []
              self.packets = []
              self.last_seq = None

          def _load(self):
              # Not at import time: GRC also runs this file, from somewhere else, to read the ports
              sys.path.insert(0, os.path.join(os.path.dirname(os.path.abspath(__file__)), '..'))
              import fsk_decode
              self.fd = fsk_decode
              self.sync = fsk_decode.FrameSync()
              self.pattern = fsk_decode.PATTERNS.get(self.expect)
              if self.expect == 'greenbear':
                  import greenbear_packet
                  self.gbp = greenbear_packet

          def work(self, input_items, output_items):
              if self.fd is None:
                  self._load()
              for r in self.sync.feed(np.array(input_items[0])):
                  self.frames.append(r)
                  print(self._format(r), flush=True)
                  if self.gbp is not None and r['fcs_ok']:
                      print(self._greenbear(r), flush=True)
              return len(input_items[0])

          def _format(self, r):
              good = sum(f['fcs_ok'] for f in self.frames)
              line = (f"[{len(self.frames):4}] len={r['len']} fcs={'ok ' if r['fcs_ok'] else 'BAD'} ok={good}"
                      f" pol={'+' if r['polarity'] > 0 else '-'} sync_err={r['sync_errors']}"
                      f" offset={r['offset'] / 1e3:+5.1f}kHz dev={r['deviation'] / 1e3:4.1f}kHz")
              if self.pattern:
                  errors, total = self.fd.count_bit_errors(r['psdu'][:-self.fd.FCS_LEN], self.pattern)
                  line += f" bit_err={errors}/{total}"
              return line + f" {r['psdu'][:32]!r}"

          def _greenbear(self, r):
              logical = r['psdu'][:-self.fd.FCS_LEN]
              try:
                  pkt = self.gbp.parse(logical)
              except ValueError as e:
                  return f"      greenbear parse: {e}"
              self.packets.append(pkt)
              line = f"      greenbear {self.gbp.format_header(pkt)}"
              if self.last_seq is not None:
                  missed = (pkt.seq - self.last_seq - 1) % 65536
                  if missed:
                      line += f" GAP missed={missed}"
              self.last_seq = pkt.seq
              return line
    expect: '''greenbear'''
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decim) / (2 * math.pi * fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.01'
    threshold: sq_thresh
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Must lock within the 64 bit preamble. Slower loops slip bits mid-frame on simulated captures
    damping: '1.0'
    loop_bw: '0.15'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-500e3 + offset_hz'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 50e3, 40e3)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Need to check baud rate (FSKC0 register?) from code
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Get threshhold frm freq sink
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: match to fs/(2pi*delta(f))
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: in case
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Source
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim
    fc: '0'
    fftsize: '1024'
    name: XIR Filter
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Source
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    marker1: '0'
    name: Demod
    nconnections: '2'
    size: '1024'
    srate: samp_rate / decim / 10
    style1: '3'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Source
    type: complex
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq + 500e3
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
    vga: '24'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: 2fsk_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: 2fsk_demod
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_moving_average_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
