options:
  parameters:
    generate_options: qt_gui
    id: fsk_demod
    output_language: python
    title: FSK_demodulator
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 900e6
    step: 1e6
    stop: 930e6
    value: 905e6
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 5e3
    stop: 50e3
    value: 25e3
    widget: counter
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: LNA Gain (dB)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: sq_thresh
  id: variable_qtgui_range
  parameters:
    label: sq
    min_len: '100'
    start: '-100'
    step: '1'
    stop: '0'
    value: '-75'
    widget: counter
  states: {}
- name: decim
  id: variable
  parameters:
    comment: 500 kS/s after the filter, so 10 samples per symbol
    value: '16'
  states: {}
- name: offset_hz
  id: variable_qtgui_range
  parameters:
    comment: Frequency offset between the radios. Set it from the decoder's offset= output
    label: Offset (Hz)
    start: '-50e3'
    step: '500'
    stop: 50e3
    value: '0'
  states: {}
- name: vga_gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: amp
  id: variable
  parameters:
    comment: HackRF front-end amplifier, on or off
    value: 'False'
  states: {}
- name: record_iq
  id: variable_qtgui_check_box
  parameters:
    comment: Raw 8 MS/s capture into the log directory, 16 MB/s (57.6 GB per hour)
    'false': 'False'
    label: Record IQ
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: log_dir
  id: parameter
  parameters:
    comment: Empty means ground-station/logs, found from the script's path. Command line --log-dir
    label: Log directory
    type: str
    value: ''
  states: {}
- name: logs
  id: variable
  parameters:
    value: os.path.abspath(log_dir or os.path.join(os.path.dirname(os.path.abspath(sys.argv[0])), os.pardir, 'logs'))
  states: {}
- name: run_id
  id: variable
  parameters:
    comment: UTC start of this run, so every run gets new files
    value: time.strftime('%Y%m%dT%H%M%SZ', time.gmtime())
  states: {}
- name: log_file
  id: variable
  parameters:
    value: os.path.join(logs, run_id + '.log')
  states: {}
- name: iq_file
  id: variable
  parameters:
    comment: A new file each time Record IQ is ticked, named by its UTC start time
    value: os.path.join(logs, time.strftime('%Y%m%dT%H%M%SZ', time.gmtime()) + '.iq') if record_iq else os.devnull
  states: {}
- name: import_0
  id: import
  parameters:
    imports: |-
      import os
      import sys
      import time
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    comment: Passes samples only while Record IQ is ticked
    enabled: record_iq
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    comment: The same bytes as hackrf_transfer, so fsk_decode.py reads the file
    scale_factor: '128.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_file
    type: byte
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: One symbol, matched to the rectangular FSK pulse
    length: '10'
    max_iter: '4000'
    scale: '0.1'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Decodes the hat's MR-FSK frames from the symbol sync's soft symbols, prints them, and writes them
      to the run's text log with a UTC time. The frame logic is FrameSync in ground-station/fsk_decode.py.
      The log also records each receiver setting when it changes, and when IQ recording starts and stops.

      expect='greenbear' -> Green Bear packets from software/tests/usb-bridge (greenbear_packet.py): the header,
                            sequence gaps, and the whole message on the lines under each frame
      expect='tx-burst'  -> bit errors against the tx-burst pattern. The old app's 128-byte frames parse in this mode
      """
      import os
      import sys
      import time

      import numpy as np
      from gnuradio import gr

      # Flowgraph variables passed in so their changes are logged. GRC calls the setters from the sliders
      SETTINGS = ('freq', 'rf_gain', 'vga_gain', 'amp', 'offset_hz', 'sq_thresh', 'iq_file')


      def utc():
          t = time.time()
          return time.strftime('%Y-%m-%dT%H:%M:%S', time.gmtime(t)) + f'.{int(t % 1 * 1000):03d}Z'


      def _setting(name):
          def get(self):
              return self.settings.get(name)

          def put(self, value):
              if self.settings.get(name) != value:
                  self.settings[name] = value
                  if name == 'iq_file':
                      self._write('# iq ' + ('off' if value == os.devnull else f'recording to {value}'))
                  else:
                      self._write(f'# {name}={value}')
          return property(get, put)


      class blk(gr.sync_block):
          """OCS-RF frame decoder"""

          def __init__(self, expect='greenbear', log_file='', samp_rate=0.0, freq=0.0, rf_gain=0.0, vga_gain=0.0,
                       amp=False, offset_hz=0.0, sq_thresh=0.0, iq_file=''):
              gr.sync_block.__init__(self, name='OCS-RF frame decoder', in_sig=[np.float32], out_sig=None)
              self.expect = expect
              self.fd = None
              self.frames = []
              self.settings = {}
              self.log = None
              # Empty when GRC builds the block only to read its ports
              if log_file:
                  os.makedirs(os.path.dirname(os.path.abspath(log_file)), exist_ok=True)
                  self.log = open(log_file, 'a', buffering=1)
                  self._write(f'# fsk_demod start, samp_rate={samp_rate:g}, log {log_file}')
              self.freq, self.rf_gain, self.vga_gain, self.amp = freq, rf_gain, vga_gain, amp
              self.offset_hz, self.sq_thresh, self.iq_file = offset_hz, sq_thresh, iq_file

          def _load(self):
              # Not at import time: GRC also runs this file, from somewhere else, to read the ports
              sys.path.insert(0, os.path.join(os.path.dirname(os.path.abspath(__file__)), '..'))
              import fsk_decode
              self.fd = fsk_decode
              self.sync = fsk_decode.FrameSync()
              self.link = fsk_decode.AppLink()
              self.gb = fsk_decode.GreenBearLink() if self.expect == 'greenbear' else None
              self.pattern = fsk_decode.PATTERNS.get(self.expect)

          def _write(self, text):
              if self.log:
                  self.log.write(f'{utc()} {text}\n')

          def work(self, input_items, output_items):
              if self.fd is None:
                  self._load()
              for r in self.sync.feed(np.array(input_items[0])):
                  self.frames.append(r)
                  for line in self._format(r):
                      print(line, flush=True)
                      self._write(line)
              return len(input_items[0])

          def stop(self):
              self._write(f'# fsk_demod stop, {len(self.frames)} frames')
              return True

          def _format(self, r):
              good = sum(f['fcs_ok'] for f in self.frames)
              line = (f"[{len(self.frames):4}] len={r['len']} fcs={'ok ' if r['fcs_ok'] else 'BAD'} ok={good}"
                      f" pol={'+' if r['polarity'] > 0 else '-'} sync_err={r['sync_errors']}"
                      f" offset={r['offset'] / 1e3:+5.1f}kHz dev={r['deviation'] / 1e3:4.1f}kHz")
              if r['snr'] is not None:
                  line += f" snr={r['snr']:4.1f}dB"
              if self.gb:
                  gb = self.gb.update(r['psdu'], r['fcs_ok'])
                  return [line + f" {r['psdu'][:32]!r}"] + (self.fd.format_greenbear(gb) if gb else [])
              app = self.link.update(r['psdu'], r['fcs_ok'])
              if app:
                  return [f"{line} {self.fd.format_app(app)}"]
              if self.pattern:
                  errors, total = self.fd.count_bit_errors(r['psdu'][:-self.fd.FCS_LEN], self.pattern)
                  line += f" bit_err={errors}/{total}"
              return [line + f" {r['psdu'][:32]!r}"]


      for _name in SETTINGS:
          setattr(blk, _name, _setting(_name))
    amp: amp
    expect: '''greenbear'''
    freq: freq
    iq_file: iq_file
    log_file: log_file
    offset_hz: offset_hz
    rf_gain: rf_gain
    samp_rate: samp_rate
    sq_thresh: sq_thresh
    vga_gain: vga_gain
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decim) / (2 * math.pi * fsk_deviation)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.01'
    threshold: sq_thresh
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: Must lock within the 64 bit preamble. Slower loops slip bits mid-frame on simulated captures
    damping: '1.0'
    loop_bw: '0.15'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-500e3 + offset_hz'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 50e3, 40e3)
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    note: Need to check baud rate (FSKC0 register?) from code
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Get threshhold frm freq sink
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: match to fs/(2pi*delta(f))
  states: {}
- name: note_0_0_1
  id: note
  parameters:
    note: in case
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Source
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim
    fc: '0'
    fftsize: '1024'
    name: XIR Filter
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Source
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    marker1: '0'
    name: Demod
    nconnections: '2'
    size: '1024'
    srate: samp_rate / decim / 10
    style1: '3'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Source
    type: complex
  states: {state: disabled}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: amp
    center_freq: freq + 500e3
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: 2fsk_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: 2fsk_demod
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_copy_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_moving_average_xx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_moving_average_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', blocks_copy_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
